# Keil uVision project LPC5411x_IAP.uvprojx, settings and files
target LPC5411X_IAP_128 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0-Beta99
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: LPC5411x_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: LPC5411X FLASH_128
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target LPC5411X_IAP_256 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0-Beta99
  cpu: as above
  output: LPC5411x_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: LPC5411X FLASH_256
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
software components: CMSIS:CORE 5.0.0
