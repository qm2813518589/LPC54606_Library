# Keil uVision project MassStorage.uvprojx, settings and files
target LPC54114 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0-dev1
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) IRAM2(0x20020000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MassStorage
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  group Source
    ./: MassStorage.c USBD_User_MSC_0.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, File System:CORE 6.6.2, File System:Drive:Memory Card 6.6.2, USB:CORE 6.6.16, USB:Device 6.6.16, USB:Device:MSC 6.6.16, CMSIS Driver:SPI:SPI 1.0, CMSIS Driver:USB Device 1.0, Compiler:I/O:File 1.0.0, Device:LPCOpen 3.1.0, Device:Startup 3.1.0
