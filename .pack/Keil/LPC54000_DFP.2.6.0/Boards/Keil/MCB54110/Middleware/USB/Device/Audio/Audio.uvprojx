# Keil uVision project Audio.uvprojx, settings and files
target LPC54114 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.3.0-dev1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20020000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Audio
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  group Source
    ./: Audio.c USBD_User_ADC_Audio_0.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:Audio:Audio 1.0.0, Board Support:Audio:Codec 1.0.0, Board Support:Audio:Microphone 1.0.0, USB:CORE 6.8.0, USB:Device 6.8.0, USB:Device:ADC 6.8.0, CMSIS Driver:I2C 1.0, CMSIS Driver:SAI 1.1, CMSIS Driver:USB Device 1.0, Device:LPCOpen 3.00c.001, Device:Startup 3.1.0
