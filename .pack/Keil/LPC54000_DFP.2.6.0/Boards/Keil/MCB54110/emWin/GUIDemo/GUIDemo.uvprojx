# Keil uVision project GUIDemo.uvprojx, settings and files
target LPC54114 Flash (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.6.0-dev0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) IRAM2(0x20020000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GUIDemo
  c flags: Optim=4
  c define: GUIDEMO_SUPPORT_CURSOR
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:Joystick 1.0.0, Board Support:Touchscreen:STMPE811 1.0.0, Board Support:emWin LCD 1.0.0, CMSIS Driver:I2C 1.0, CMSIS Driver:SPI:SPI 1.0, Device:LPCOpen 3.1.0, Device:Startup 3.1.0, Graphics:CORE 5.30.0, Graphics:Demo:ColorBar 5.30.0, Graphics:Demo:Cursor 5.30.0, Graphics:Demo:Framework 5.30.0, Graphics:Demo:Speed 5.30.0, Graphics:Demo:TransparentDialog 5.30.0, Graphics:Display:MCBQVGA_LG 5.30.0, Graphics:Input Device:Joystick 5.30.0, Graphics:Input Device:Touchscreen 5.30.0
