# Keil uVision project Blinky.uvprojx, settings and files
target LPC54114 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0-dev1
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  group Source Group 1
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target LPC54114 RAM (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0-dev1
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  asm define: NO_CRP
  memory RVCT4: ROM 0x4000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x28000
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:LED 1.0.0, Device:LPCOpen 3.00c.001, Device:Startup 3.1.0
