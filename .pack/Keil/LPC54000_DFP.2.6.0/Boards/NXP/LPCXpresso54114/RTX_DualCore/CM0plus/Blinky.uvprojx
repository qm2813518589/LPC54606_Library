# Keil uVision project Blinky.uvprojx, settings and files
target LPC54114 M0+ Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54114J256BD64:M0plus NXP
  pack: Keil.LPC54000_DFP.2.2.0-dev1
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) IRAM2(0x20020000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x20000 size 0x20000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x20020000 size 0x8000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:LED 1.0.0, Device:LPCOpen 3.1.0, Device:Startup 3.1.0
