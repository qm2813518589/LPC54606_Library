# Keil uVision project Blinky.uvprojx, settings and files
target LPC54608 Flash (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC54608J512BD208:M4 NXP
  pack: Keil.LPC54000_DFP.2.4.0-dev0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  group Source Group 1
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target LPC54608 RAM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC54608J512BD208:M4 NXP
  pack: Keil.LPC54000_DFP.2.4.0-dev0
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  asm define: NO_CRP
  memory RVCT4: ROM 0x4000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x28000
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.2.0
