# Keil uVision project Blinky.uvprojx, settings and files
target LPC54102 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54102J512BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0-dev1
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target LPC54102 RAM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC54102J512BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0-dev1
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  asm define: NO_CRP
  memory RVCT4: ROM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
target LPC54102 SWO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC54102J512BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0-dev1
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
software components: CMSIS:CORE 5.0.0, Board Support:LED 1.0.0, Compiler:I/O:STDOUT 1.0.0, Device:LPCOpen 3.1.0, Device:Startup 3.1.0
