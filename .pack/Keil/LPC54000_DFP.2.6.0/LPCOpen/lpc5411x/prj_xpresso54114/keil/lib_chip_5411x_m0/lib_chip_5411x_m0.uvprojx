# Keil uVision project lib_chip_5411x_m0.uvprojx, settings and files
target lib_chip_5411x_m0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC54114J256BD64:M0plus NXP
  pack: Keil.LPC54000_DFP.1.2.0-dev2
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) IRAM2(0x20020000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lib_chip_5411x_m0 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CHIP_LPC5411X CORE_M0PLUS
  c include: ..\..\..\chip_5411x\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  group src
    ../../../chip_5411x/src/: timer_5411x.c sysinit_5411x.c syscon_5411x.c stopwatch_5411x.c sct_pwm_5411x.c sct_5411x.c rtc_ut.c ring_buffer.c pll_5411x.c iap.c fpu_init.c clock_5411x.c chip_5411x.c adc_5411x.c dma_5411x.c i2cm_5411x.c i2cs_5411x.c spi_common_5411x.c spim_5411x.c spis_5411x.c uart_5411x.c dma_service_5411x.c dmic_5411x.c flexcomm_5411x.c i2s_5411x.c
