<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lib_chip_5410x\lib_chip_5410x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lib_board_lpcxpresso_54102\lib_board_lpcxpresso_54102.ewp</path>
  </project> 
  <project>
    <path>$WS_DIR$\periph_adc\periph_adc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_blinky\periph_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_bod\periph_bod.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_clkout\periph_clkout.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_crc\periph_crc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_dma\periph_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_flashiap\periph_flashiap.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_freqmeasure\periph_freqmeasure.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_gint\periph_gint.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2c_probe\periph_i2c_probe.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2cm_interrupt\periph_i2cm_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2cs_interrupt\periph_i2cs_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2cs_interrupt_dma\periph_i2cs_interrupt_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_mrt\periph_mrt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_pinint\periph_pinint.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_pllfract\periph_pllfract.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_pmu\periph_pmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_ritimer\periph_ritimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_rtc\periph_rtc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_rtcut\periph_rtcut.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_sct\periph_sct.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_sct_pwm\periph_sct_pwm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_spi_sm_int\periph_spi_sm_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_timer\periph_timer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_uart_rb\periph_uart_rb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_utick\periph_utick.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_wwdt\periph_wwdt.ewp</path>
  </project>
  <batchBuild/>
</workspace>


