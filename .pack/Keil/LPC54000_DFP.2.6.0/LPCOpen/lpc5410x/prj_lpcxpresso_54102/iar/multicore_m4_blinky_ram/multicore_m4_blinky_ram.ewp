# IAR project multicore_m4_blinky_ram.ewp, settings and files
configuration iflash_nxp_lpcxpresso_54102 (ARM)
  General.OGChipSelectEditMenu: LPC54102J512_M4 NXP LPC54102J512_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4; CHIP_LPC5410X; M0_IMAGE_IN_RAM; M0_BOOT_STACKADDR=0x02010000
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\chip_5410x\inc; ..\..\..\lpcxpresso_54102\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: multicore_m4_blinky_ram.bin
  ILINK.IlinkOutputFile: multicore_m4_blinky.out
  ILINK.IlinkKeepSymbols: m0_image_start
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../chip_5410x/startup/: iar_startup_lpc5410x.s sysinit.c
    ../../../examples_5410x/multicore_m4master_blinky/src/: m4master_blinky.c
    ../../../examples_5410x/multicore_m4master_blinky/: readme.txt
  group lib
    ../lib_board_lpcxpresso_54102/iar_output/Exe/: board_lpcxpresso_54102.a
    ../lib_chip_5410x/iar_output/Exe/: chip_5410x_lib.a
    ../../../chip_5410x/libs/: iar_lib_power.a
