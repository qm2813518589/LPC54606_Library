# IAR project freertos_blinky.ewp, settings and files
configuration iflash_nxp_lpcxpresso_54102 (ARM)
  General.OGChipSelectEditMenu: LPC54101J512_M4 NXP LPC54101J512_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4; CHIP_LPC5410X
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\chip_5410x\inc; ..\..\..\lpcxpresso_54102\inc; ..\..\..\..\freertos\freertos\Source\include; ..\..\..\..\freertos\freertos\Source\portable\IAR\ARM_CM4F; ..\..\..\examples_5410x\freertos_blinky\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\examples_5410x\freertos_blinky\inc
  OBJCOPY.OOCOutputFile: freertos_blinky.bin
  ILINK.IlinkOutputFile: freertos_blinky.out
  ILINK.IlinkIcfFile: freertos_blinky.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group example
    ../../../examples_5410x/freertos_blinky/src/: blinky.c
    ../../../chip_5410x/startup/: iar_startup_lpc5410x.s sysinit.c
    ../../../examples_5410x/freertos_blinky/: readme.txt
  group freertos
    ../../../../freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../freertos/freertos/Source/: list.c queue.c tasks.c timers.c
    ../../../../freertos/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group lib
    ../lib_board_lpcxpresso_54102/iar_output/Exe/: board_lpcxpresso_54102.a
    ../lib_chip_5410x/iar_output/Exe/: chip_5410x_lib.a
    ../../../chip_5410x/libs/: iar_lib_power.a
