# Keil uVision project lib_chip_5410x_m0.uvprojx, settings and files
target lib_chip_5410x_m0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC54102J512BD64:M0plus NXP
  pack: Keil.LPC54000_DFP.1.2.0-dev0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lib_chip_5410x_m0 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CHIP_LPC5410X CORE_M0PLUS
  c include: ..\..\..\chip_5410x\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  group src
    ../../../chip_5410x/src/: wwdt_5410x.c timer_5410x.c sysinit_5410x.c syscon_5410x.c stopwatch_5410x.c sct_pwm_5410x.c sct_5410x.c rtc_ut.c ritimer_5410x.c ring_buffer.c pll_5410x.c pinint_5410x.c iocon_5410x.c iap.c gpiogroup_5410x.c gpio_5410x.c fpu_init.c fifo_5410x.c crc_5410x.c clock_5410x.c chip_5410x.c adc_5410x.c dma_5410x.c i2cm_5410x.c i2cs_5410x.c spi_common_5410x.c spim_5410x.c spis_5410x.c uart_5410x.c
software components: CMSIS:CORE 5.0.0
