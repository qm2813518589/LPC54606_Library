# Keil uVision project freertos_blinky.uvprojx, settings and files
target iflash_nxp_lpcxpresso_lpc5410x (ARM-ADS)
  device: LPC54102J512BD64:M4 NXP
  pack: Keil.LPC54000_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_blinky
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CHIP_LPC5410X CORE_M4
  c include: ..\..\..\chip_5410x\inc;..\..\..\lpcxpresso_54102\inc;..\..\..\..\freertos\freertoslpc;..\..\..\..\freertos\freertos\Source\include;..\..\..\..\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\..\..\examples_5410x\freertos_blinky\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  group src
    ../../../examples_5410x/freertos_blinky/src/: blinky.c keil_startup_lpc5410x.s
    ../../../chip_5410x/startup/: sysinit.c
    ../../../../freertos/freertos/Source/: timers.c tasks.c queue.c list.c croutine.c
    ../../../../freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../freertos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
  group libs
    ../lib_chip_5410x/keil_output/core_m4/: lib_chip_5410x.lib
    ../lib_board_lpcxpresso_54102/keil_output/core_m4/: lib_board_lpcxpresso_lpc54102.lib
    ../../../chip_5410x/libs/: keil_lib_power.lib
