# Keil uVision project lib_board_lpcxpresso_54102.uvprojx, settings and files
target lib_board_lpcxpresso_lpc54102 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC54102J512BD64:M4 NXP
  pack: Keil.LPC54000_DFP.1.2.0-dev0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lib_board_lpcxpresso_lpc54102 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CHIP_LPC5410X CORE_M4
  c include: ..\..\..\chip_5410x\inc;..\..\..\lpcxpresso_54102\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  group src
    ../../../lpcxpresso_54102/src/: board.c board_sysinit.c
software components: CMSIS:CORE 5.0.0
