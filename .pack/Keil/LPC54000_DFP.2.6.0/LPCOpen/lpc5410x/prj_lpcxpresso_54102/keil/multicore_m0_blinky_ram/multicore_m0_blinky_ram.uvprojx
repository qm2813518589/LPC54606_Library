# Keil uVision project multicore_m0_blinky_ram.uvprojx, settings and files
target iram_nxp_lpc5410x (ARM-ADS)
  device: LPC54102J512BD64:M0plus NXP
  pack: Keil.LPC54000_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: m0_blinky_ram
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CHIP_LPC5410X CORE_M0PLUS __MULTICORE_M0SLAVE
  c include: ..\..\..\chip_5410x\inc;..\..\..\lpcxpresso_54102\inc
  asm define: SLAVEBOOT NO_CRP
  memory RVCT4: ROM 0x20000 size 0x60000
  memory RVCT9: RAM 0x2010000 size 0x8000
  group example
    ../../../examples_5410x/multicore_m0slave_blinky/: readme.txt
    ../../../examples_5410x/multicore_m0slave_blinky/src/: m0slave_blinky.c
    ../../../chip_5410x/startup/: sysinit.c keil_startup_lpc5410x-m0.s
  group lib
    ../lib_chip_5410x_m0/keil_output/core_m0/: lib_chip_5410x_m0.lib
    ../../../chip_5410x/libs/: keil_lib_power_m0.lib
